# Keil uVision project FS-STM32U575-Total.uvprojx, settings and files
target FS-STM32U575-Total (6160000::V6.16::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: FS-STM32U575-Total +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,LINK_HARDWARE
  c include: ../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../Core/Inc;../Drivers/Motion_Driver;../Drivers/efsm-master/efsm;../Drivers/MAX30102_Maxim;./Middlewares;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  memory RVCT1: ROM 0x90000000 size 0x1000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: .\FS-STM32U575-Total\My_Fixed_Layout.sct
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: user_app.c bsp_ft6336.c bsp_ili9341_4line.c bsp_ospi_w25q128.c bsp_ap3216c.c bsp_sht20.c bsp_mq2.c bsp_mq3.c bsp_motor.c bsp_max30102.c bsp_esp8266.c main.c gpio.c adc.c crc.c gpdma.c i2c.c icache.c octospi.c rtc.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c bsp_scd41.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDMA.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group gui
    ../touchgfx/gui/src/applicationpage_screen/: applicationpagepresenter.cpp applicationpageview.cpp
    ../touchgfx/gui/src/fivekeypage_screen/: fivekeypagepresenter.cpp fivekeypageview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/homepage_screen/: homepagepresenter.cpp homepageview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/sensorpage_screen/: sensorpagepresenter.cpp sensorpageview.cpp
    ../touchgfx/gui/src/settingpage_screen/: settingpagepresenter.cpp settingpageview.cpp
    ../touchgfx/gui/src/sixaxispage_screen/: sixaxispagepresenter.cpp sixaxispageview.cpp
    ../touchgfx/gui/src/startuppage_screen/: startuppagepresenter.cpp startuppageview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_cambriaz_40_4bpp_0.cpp font_consolaz_20_4bpp_0.cpp font_consolaz_40_4bpp_0.cpp font_constanz_20_4bpp_0.cpp font_simkai_20_4bpp_0.cpp font_simkai_20_4bpp_10.cpp font_simkai_20_4bpp_11.cpp font_simkai_20_4bpp_12.cpp font_simkai_20_4bpp_13.cpp font_simkai_20_4bpp_14.cpp font_simkai_20_4bpp_16.cpp font_simkai_20_4bpp_17.cpp font_simkai_20_4bpp_18.cpp font_simkai_20_4bpp_4.cpp font_simkai_20_4bpp_9.cpp font_simyou_ttf_10_4bpp_0.cpp font_verdana_16_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_cambriaz_40_4bpp.cpp kerning_consolaz_20_4bpp.cpp kerning_consolaz_40_4bpp.cpp kerning_constanz_20_4bpp.cpp kerning_simkai_20_4bpp.cpp kerning_simyou_ttf_10_4bpp.cpp kerning_verdana_16_4bpp.cpp table_cambriaz_40_4bpp.cpp table_consolaz_20_4bpp.cpp table_consolaz_40_4bpp.cpp table_constanz_20_4bpp.cpp table_simkai_20_4bpp.cpp table_simyou_ttf_10_4bpp.cpp table_verdana_16_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/gui_generated/src/applicationpage_screen/: applicationpageviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_co2_1.cpp image_heart_rate_1.cpp image_heart_rate_2.cpp image_humidity_1.cpp image_locked.cpp image_locked2.cpp image_modal_co2_bg.cpp image_modal_heart_bg.cpp image_modal_hum_bg.cpp image_modal_temp2_bg.cpp image_modal_temp3_bg.cpp image_modal_temp_bg.cpp image_mti_temp_1.cpp image_zhujiemian.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/fivekeypage_screen/: fivekeypageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/homepage_screen/: homepageviewbase.cpp
    ../touchgfx/generated/images/src/applicationpage/: image_add_36x36.cpp image_add_pressed_36x36.cpp image_applicationpage_background-240x320.cpp image_dc_fan_54x54.cpp image_dc_fan__pressed_54x54.cpp image_flame_54x54.cpp image_flame_no_fire_54x54.cpp image_heartrate_54x55.cpp image_heartrate_end_80x80.cpp image_heartrate_pressed__54x55.cpp image_heartrate_start_80x80.cpp image_img_20260515_192616.cpp image_modalheartrate_background.cpp image_modalnixietube_background.cpp image_nixietube_0_54x76.cpp image_nixietube_1_54x76.cpp image_nixietube_2_54x76.cpp image_nixietube_3_54x76.cpp image_nixietube_4_54x76.cpp image_nixietube_5_54x76.cpp image_nixietube_6_54x76.cpp image_nixietube_7_54x76.cpp image_nixietube_8_54x76.cpp image_nixietube_9_54x76.cpp image_nixietube_checked_0_54x76.cpp image_nixietube_checked_1_54x76.cpp image_nixietube_checked_2_54x76.cpp image_nixietube_checked_3_54x76.cpp image_nixietube_checked_4_54x76.cpp image_nixietube_checked_5_54x76.cpp image_nixietube_checked_6_54x76.cpp image_nixietube_checked_7_54x76.cpp image_nixietube_checked_8_54x76.cpp image_nixietube_checked_9_54x76.cpp image_nixietube_pressed_54x147.cpp image_nixietube_release_54x147.cpp image_subtract_36x36.cpp image_subtract_pressed_36x36.cpp image_vibrate_54x68.cpp image_vibrate_pressed_54x68.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_backgrounds_320x240_puzzle.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_off.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_off_pressed.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_on_dark.cpp image_alternate_theme_images_widgets_radiobutton_radio_medium_rounded_on_pressed.cpp image_icon_theme_images_action_backup_50_50_e8f6fb.svg.cpp image_icon_theme_images_action_done_50_50_e8f6fb.svg.cpp
    ../touchgfx/generated/images/src/settingpage/: image_alternate_theme_images_widgets_slider_horizontal_thin_filler_small.cpp image_alternate_theme_images_widgets_slider_horizontal_thin_rounded_light.cpp image_alternate_theme_images_widgets_slider_horizontal_thin_track_small.cpp image_settingpage_background-240x320.cpp
    ../touchgfx/generated/images/src/controls/: image_application-54x54.cpp image_application_pressed-54x54.cpp image_buttons-54x54.cpp image_buttons-54x54_pressed.cpp image_closedmodalwifi_36x36.cpp image_closedmodalwifi_pressed_36x36.cpp image_gyroscope-54x54.cpp image_gyroscope-54x54_pressed.cpp image_image_menu_icon.cpp image_image_menu_icon_pressed.cpp image_menu_icon.cpp image_menu_icon_pressed.cpp image_setting-54x54.cpp image_setting-54x54_pressed.cpp image_wifi_rssi_1_signal.cpp image_wifi_rssi_2_signal.cpp image_wifi_rssi_3_signal.cpp image_wifi_rssi_4_signal.cpp image_wifi_rssi_no_signal.cpp image_wifilink-36x49.cpp image_wifilink-36x49_pressed.cpp image_wifilink-54x54.cpp image_wifilink_pressed-54x54.cpp
    ../touchgfx/generated/images/src/sixaxispage/: image_eulerangle-288x240.cpp image_sixaxispage_background-240x320.cpp
    ../touchgfx/generated/images/src/fivekeypage/: image_five_keydown-200x200.cpp image_five_keyleft-200x200.cpp image_five_keynoppress-200x200.cpp image_five_keyok-200x200.cpp image_five_keyright-200x200.cpp image_five_keyup-200x200.cpp image_fivekeypage_background-240x320.cpp
    ../touchgfx/generated/images/src/homepage/: image_homepage_background-240x320.cpp image_modalwifi_background.cpp image_spaceman-64x80.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/sensorpage_screen/: sensorpageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/settingpage_screen/: settingpageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/sixaxispage_screen/: sixaxispageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/startuppage_screen/: startuppageviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m33/Keil6.x/: touchgfx_core_wchar16.lib
  group Motion_Driver
    ../Drivers/Motion_Driver/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group efsm-master
    ../Drivers/efsm-master/efsm/: efsm.c efsm_hal.c
  group MAX30102_Maxim
    ../Drivers/MAX30102_Maxim/: algorithm.c max30102.c
  group Middlewares
    ../../../dx_nf01/dx_nf01/MDK-ARM/Middlewares/: uart_receiver.h uart_receiver.c
software components: CMSIS:CORE 5.6.0
